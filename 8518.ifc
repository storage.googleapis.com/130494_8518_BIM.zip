Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-06T23:22:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 06 23:22:04 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{5C1607FD-1E62-445D-99D5-2BD9414E347D}\ifc * Database version: 5507 * Database creation date: Mon Aug 06 23:22:03 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 06 23:22:04 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 06 23:22:04 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8518 Bidet faucet, 8518:8518 Bidet faucet:347069
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 135.5 mm; NominalHeight: 162.3 mm; NominalWidth: 48 mm; Projection: 119 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8518; ConvergoRefNr: 0087-1809-0016-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_87_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_30_96_07; Version: 1; VersionDate: 27/07/2018
Type - Green Building Properties(Type) - EAN Number: 6414150045073; EN Standard: EN 817; LVI Number: 6118520; Noise Class: II (ISO 3822); RSK Number: 8553320; Sintef Certificate: Sintef Nr. 0967; VVS Number: 705275004
Type - Identity Data(Type) - Class: Single lever; Group: Bidet faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;POL;RUS;SWE;UKR; Model: 8518 Bidet faucet; Name_en: 8518 Bidet faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 8518; Product Datasheet: https://www.oras.com/datasheet/8518/en; Product Family: IL BAGNO ALESSI One by Oras; Product URL: https://www.oras.com/en/products/oras/product/8518; Type Name: 8518 Bidet faucet; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: Swivel aerator; Connection Size: Ø10 mm; Extensions: Pop-up waste with draw-rod; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110214_PDM_945450_C_(945450-01-16).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Copper inlet pipe(s); Pressure Loss With Flow 01ls: 75000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP8518/; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8518; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8518; Name: 8518 Bidet faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x135x162.5 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8518; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8518 Bidet faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0374241 m2; Volume: 0.00106174 m3
Identity Data - Mark: 18
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8518: 8518 Bidet faucet; Family and Type: 8518: 8518 Bidet faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8518: 8518 Bidet faucet; Type Id: 8518: 8518 Bidet faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
